# Keil uVision project bootloader.uvprojx, settings and files
target stm32g030f6p6 (6230000::V6.23::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./: app.c crc32.c debug.c flash.c gpio.c main.c program_flash.c sw_timebase.c
  group inc
    ./: app.h crc32.h debug.h flash.h gpio.h program_flash.h sw_timebase.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.4.2
